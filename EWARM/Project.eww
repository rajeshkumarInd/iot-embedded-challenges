<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FREERTOS_STM32F302.ewp</path>
  </project>
  <batchBuild />
</workspace>
